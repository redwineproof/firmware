## general/package/sstarts/Config.in
```kconfig
config BR2_PACKAGE_SSTARTS
	bool "Build BR2_PACKAGE_SSTARTS kernel module"
	help
		This is a kernel module for sstarts.
```
